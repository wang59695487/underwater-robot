# Keil uVision project Fly_Vehicle.uvprojx, settings and files
target Fly_Vehicle (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Fly_Vehicle +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;                             ../Drivers/STM32F1xx_HAL_Driver/Inc;                             ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                             ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                             ../Drivers/CMSIS/Include;                             ..\USER;                             ..\USER\DRIVER;                             ..\USER\CONTROL;                             ..\USER\TASK
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c freertos.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group DRIVER
    ../USER/DRIVER/: board.c batt.c led.c switch.c pwm.c myiic.c
  group SENSOR
    ../USER/DRIVER/: dht11.c mpu6050.c ms5803.c qmc5883l.c sx1278.c
  group CONTROL
    ../USER/CONTROL/: PID.c control.c stm32_pi.c
  group TASK
    ../USER/TASK/: Compass_Task.c Control_Task.c Sensor_Task.c Message_Task.c Pressure_Task.c ledTasks.c
  group ReadMe
    ../USER/: Readme.txt
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
